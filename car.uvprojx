# Keil uVision project car.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: car
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group Source Group 1
    ./: car.c camera.c drive_motors.c uart_serial.c uart_serial.h cortex_m.c cortex_m.h common.h adc.c adc.h sys_tick_timer.c sys_tick_timer.h drive_motors.h camera.h oled_display.c oled_display.h car.h periodic_timer.c periodic_timer.h common.c steer_servo.c steer_servo.h pwm.c pwm.h button.c button.h
software components: CMSIS:CORE 5.6.0, Device:Startup 3.2.2
